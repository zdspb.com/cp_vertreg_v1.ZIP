# Autodesk Inventor assembly: CP vertical reg assembly
## iProperties
Created: 2008-05
Part Number: CP vertical reg assembly
Document SubType Name: Assembly
Designer: Ydna
Author: Ydna
